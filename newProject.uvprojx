# Keil uVision project newProject.uvprojx, settings and files
target newPro (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: newProject +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: .\Libraries;.\User;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group STM32F4xx_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMISS
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group USER
    ./User/: mian.c bsp_led.c bsp_key.c bsp_exit.c bsp.c bsp_systick.c
